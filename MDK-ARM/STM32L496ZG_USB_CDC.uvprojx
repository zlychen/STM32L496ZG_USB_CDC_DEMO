# Keil uVision project STM32L496ZG_USB_CDC.uvprojx, settings and files
target STM32L496ZG_USB_CDC (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496ZG_USB_CDC +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pcd.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc.c stm32l4xx_hal_gpio.c stm32l4xx_hal.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_i2c.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User
    ../Src/: main.c gpio.c stm32l4xx_it.c usb_device.c usbd_conf.c usbd_cdc_if.c usbd_desc.c stm32l4xx_hal_msp.c
software components: CMSIS:CORE 4.1.0
